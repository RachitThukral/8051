# Keil uVision project 19.3 TSL2561_LCD.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: 19.3 TSL2561_LCD +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 19.3 TSL2561_LCD.c
